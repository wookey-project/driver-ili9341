## Kconfig
```kconfig
config USR_DRV_ILI9341
  bool  "userspace ILI9341 driver"
  default y
  ---help---
  Support for ILI9341 hardware Screen driver.
```
